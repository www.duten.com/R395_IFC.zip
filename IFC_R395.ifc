Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-11-18T11:07:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 18 11:07:11 2020 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{40C6A4E7-1461-45CB-88F6-20310E1F64D5}\ifc * Database version: 5507 * Database creation date: Wed Nov 18 11:07:09 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 18 11:07:09 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 18 11:07:09 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Battery Operated Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R395:Battery Operated Brushed Stainless Steel:311942
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Chrome, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R395:Battery Operated Chrome:311974
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Chrome; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Matte Black, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R395:Battery Operated Matte Black:311990
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_MatteBlack, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R395:Mains Operated Brushed Stainless Steel:312042
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Chrome, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R395:Mains Operated Chrome:312043
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Polished Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Matte Black, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R395:Mains Operated Matte Black:312057
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_MatteBlack, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
